# IAR project CC2531.ewp, settings and files
configuration Debug (8051, debug)
  General.OGChipSelectMenu: CC2531F256 CC2531F256
  ICC8051.CCDefines: BDB_FINDING_BINDING_CAPABILITY_ENABLED=0; TC_LINKKEY_JOIN; MAXMEMHEAP=2885; NWK_MAX_DEVICE_LIST=10; ZDSECMGR_TC_DEVICE_MAX=30; DISABLE_GREENPOWER_BASIC_PROXY; CC2531ZNP; POWER_SAVING; FEATURE_SYSTEM_STATS; MT_GP_CB_FUNC
  ICC8051.CCDiagSuppress: Pe001,Pa010
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: $PROJ_DIR$; Source; ..\Source; ..\..\SE\Source; ..\..\ZMain\TI2530ZNP; ..\..\..\..\Components\hal\include; ..\..\..\..\Components\hal\target\CC2530USB; ..\..\..\..\Components\hal\target\CC2530USB\usb\library; ..\..\..\..\Components\hal\target\CC2530USB\usb\library\cc2531; ..\..\..\..\Components\hal\target\CC2530USB\usb\class_cdc; ..\..\..\..\Components\mac\include; ..\..\..\..\Components\mac\high_level; ..\..\..\..\Components\mac\low_level\srf04; ..\..\..\..\Components\mac\low_level\srf04\single_chip; ..\..\..\..\Components\mt; ..\..\..\..\Components\osal\include; ..\..\..\..\Components\services\ecc\binary163; ..\..\..\..\Components\services\ecc\binary283; ..\..\..\..\Components\services\saddr; ..\..\..\..\Components\services\sdata; ..\..\..\..\Components\stack\af; ..\..\..\..\Components\stack\gp; ..\..\..\..\Components\stack\bdb; ..\..\..\..\Components\stack\nwk; ..\..\..\..\Components\stack\sapi; ..\..\..\..\Components\stack\sec; ..\..\..\..\Components\stack\sys; ..\..\..\..\Components\stack\zcl; ..\..\..\..\Components\stack\zdo; ..\..\..\..\Components\zmac; ..\..\..\..\Components\zmac\f8w
  ICC8051.CCOptLevel: 3
  ICC8051.CCOptStrategy: 1
  ICC8051.IccLang: 0
  XLINK.XclFile: ..\..\Tools\CC2530DB\f8w2530.xcl
configuration ZNP-without-SBL (8051)
  as the first configuration, except:
  ICC8051.CCDefines: BDB_FINDING_BINDING_CAPABILITY_ENABLED=0; TC_LINKKEY_JOIN; MAXMEMHEAP=2885; NWK_MAX_DEVICE_LIST=10; ZDSECMGR_TC_DEVICE_MAX=30; DISABLE_GREENPOWER_BASIC_PROXY; CC2531ZNP; POWER_SAVING; FEATURE_SYSTEM_STATS; MT_GP_CB_FUNC; ASSERT_RESET; MAKE_CRC_SHDW
  ICC8051.CCIncludePath2: $PROJ_DIR$; Source; ..\Source; ..\..\SE\Source; ..\..\Utilities\BootLoad\Source; ..\..\ZMain\TI2530ZNP; ..\..\..\..\Components\hal\include; ..\..\..\..\Components\hal\target\CC2530USB; ..\..\..\..\Components\hal\target\CC2530USB\usb\library; ..\..\..\..\Components\hal\target\CC2530USB\usb\library\cc2531; ..\..\..\..\Components\hal\target\CC2530USB\usb\class_cdc; ..\..\..\..\Components\mac\include; ..\..\..\..\Components\mac\high_level; ..\..\..\..\Components\mac\low_level\srf04; ..\..\..\..\Components\mac\low_level\srf04\single_chip; ..\..\..\..\Components\mt; ..\..\..\..\Components\osal\include; ..\..\..\..\Components\services\ecc\binary163; ..\..\..\..\Components\services\ecc\binary283; ..\..\..\..\Components\services\saddr; ..\..\..\..\Components\services\sdata; ..\..\..\..\Components\stack\af; ..\..\..\..\Components\stack\gp; ..\..\..\..\Components\stack\bdb; ..\..\..\..\Components\stack\nwk; ..\..\..\..\Components\stack\sapi; ..\..\..\..\Components\stack\sec; ..\..\..\..\Components\stack\sys; ..\..\..\..\Components\stack\zcl; ..\..\..\..\Components\stack\zdo; ..\..\..\..\Components\zmac; ..\..\..\..\Components\zmac\f8w
  postbuild: "..\tools\znp.bat" "..\tools" "CC2531-ZNP-without-SBL"
  XLINK.XclFile: ..\..\Tools\CC2530DB\cc2530-sb.xcl
configuration ZNP-with-SBL (8051)
  as the first configuration, except:
  ICC8051.CCDefines: BDB_FINDING_BINDING_CAPABILITY_ENABLED=0; TC_LINKKEY_JOIN; MAXMEMHEAP=2885; NWK_MAX_DEVICE_LIST=10; ZDSECMGR_TC_DEVICE_MAX=30; DISABLE_GREENPOWER_BASIC_PROXY; CC2531ZNP; POWER_SAVING; FEATURE_SYSTEM_STATS; MULTICAST_ENABLED=FALSE; MT_GP_CB_FUNC; MT_APP_CNF_FUNC; ASSERT_RESET; FAKE_CRC_SHDW
  ICC8051.CCIncludePath2: as above
  postbuild: "..\tools\znp.bat" "..\tools" "CC2531-ZNP-with-SBL"
  XLINK.XclFile: ..\tools\znp-prod.xcl
  group App
    ../Source/: OSAL_ZNP.c znp_app.c znp_app.h znp_spi.h
    Source/: znp_soc.c znp_spi.c
  group BDB
    ../../../../Components/stack/bdb/: bdb.c bdb.h bdb_FindingAndBinding.c bdb_interface.h bdb_Reporting.c bdb_Reporting.h bdb_tlCommissioning.c bdb_tlCommissioning.h bdb_touchlink.c bdb_touchlink.h bdb_touchlink_initiator.c bdb_touchlink_initiator.h bdb_touchlink_target.c bdb_touchlink_target.h
  group GP
    ../../../../Components/stack/GP/: gp_interface.h
  group HAL/Common
    ../../../../Components/hal/common/: hal_assert.c hal_drivers.c
  group HAL/Include
    ../../../../Components/hal/include/: hal_adc.h hal_assert.h hal_board.h hal_defs.h hal_drivers.h hal_flash.h hal_key.h hal_lcd.h hal_led.h hal_sleep.h hal_timer.h hal_uart.h
  group HAL/Target/CC2531ZNP/Config
    ../../../../Components/hal/target/CC2530USB/: hal_board_cfg.h
  group HAL/Target/CC2531ZNP/Drivers
    ../../../../Components/hal/target/CC2530USB/: hal_adc.c hal_dma.c hal_flash.c hal_key.c hal_lcd.c hal_led.c hal_sleep.c hal_startup.c hal_timer.c hal_uart.c
  group HAL/Target/CC2531ZNP/Includes
    ../../../../Components/hal/target/CC2530USB/: hal_aes.h hal_ccm.h hal_dma.h hal_mcu.h hal_types.h
  group HAL/Target/CC2531ZNP/USB/class_cdc
    ../../../../Components/hal/target/CC2530USB/usb/class_cdc/: usb_cdc.h usb_cdc_descriptor.s51 usb_cdc_hooks.c usb_cdc_hooks.h usb_firmware_library_config.c usb_firmware_library_config.h usb_firmware_library_headers.h
  group HAL/Target/CC2531ZNP/USB/library
    ../../../../Components/hal/target/CC2530USB/usb/library/: usb_descriptor.h usb_descriptor_parser.c usb_descriptor_parser.h usb_framework.c usb_framework.h usb_framework_structs.h usb_interrupt.h usb_reg.h usb_standard_requests.c usb_standard_requests.h usb_suspend.h
  group HAL/Target/CC2531ZNP/USB/library/cc2531
    ../../../../Components/hal/target/CC2530USB/usb/library/cc2531/: usb_board_cfg.h usb_interrupt.c usb_suspend.c
  group MAC/High Level
    ../../../../Components/mac/high_level/: mac_cfg.c mac_high_level.h mac_pib.c mac_pib.h mac_spec.h
  group MAC/Include
    ../../../../Components/mac/include/: mac_api.h
  group MAC/Low Level/Common
    ../../../../Components/mac/low_level/srf04/: mac_assert.h mac_autopend.c mac_autopend.h mac_backoff_timer.c mac_backoff_timer.h mac_low_level.c mac_low_level.h mac_radio.c mac_radio.h mac_rx.c mac_rx.h mac_rx_onoff.c mac_rx_onoff.h mac_sleep.c mac_sleep.h mac_tx.c mac_tx.h
  group MAC/Low Level/System
    ../../../../Components/mac/low_level/srf04/single_chip/: mac_csp_tx.c mac_csp_tx.h mac_mcu.c mac_mcu.h mac_mem.c mac_mem.h mac_radio_defs.c mac_radio_defs.h mac_rffrontend.c
  group MT
    ../../../../Components/mt/: DebugTrace.c DebugTrace.h MT.c MT.h MT_AF.c MT_AF.h MT_APP.c MT_APP.h MT_APP_CONFIG.c MT_APP_CONFIG.h MT_DEBUG.c MT_DEBUG.h MT_GP.c MT_GP.h MT_NWK.c MT_NWK.h MT_RPC.h MT_SAPI.c MT_SAPI.h MT_SYS.c MT_SYS.h MT_TASK.c MT_TASK.h MT_UART.c MT_UART.h MT_UTIL.c MT_UTIL.h MT_VERSION.c MT_VERSION.h MT_ZDO.c MT_ZDO.h MT_ZNP.c MT_ZNP.h
  group NWK
    ../../../../Components/stack/nwk/: AddrMgr.h APS.h aps_frag.h aps_groups.h aps_util.h APSMEDE.h AssocList.h BindingTable.c BindingTable.h NLMEDE.h nwk.h nwk_bufs.h nwk_globals.c nwk_globals.h nwk_util.h reflecttrack.h rtg.h stub_aps.c stub_aps.h
    ../../../../Components/stack/sys/: ZDiags.c ZDiags.h ZGlobals.c ZGlobals.h
  group OSAL
    ../../../../Components/osal/include/: comdef.h OSAL.h OSAL_Clock.h OSAL_Memory.h OSAL_Nv.h OSAL_PwrMgr.h OSAL_Tasks.h OSAL_Timers.h ZComDef.h
    ../../../../Components/osal/common/: OSAL.c OSAL_Clock.c OSAL_Memory.c OSAL_PwrMgr.c OSAL_Timers.c
    ../../../../Components/osal/mcu/cc2530/: OSAL_Math.s51 OSAL_Nv.c
  group Profile
    ../../../../Components/stack/af/: AF.c AF.h
    ../../../../Components/stack/sapi/: sapi.c sapi.h
    ../../../../Components/stack/zcl/: zcl.c zcl.h zcl_key_establish.c zcl_key_establish.h
  group Security
    ../../../../Components/stack/sec/: eccapi.h ssp.h ssp_hash.h
  group Services
    ../../../../Components/services/saddr/: saddr.c saddr.h
  group Tools
    ../../Tools/CC2530DB/: f8wConfig.cfg f8wZCL.cfg
    ../Source/: znp.cfg
  group ZDO
    ../../../../Components/stack/zdo/: ZDApp.c ZDApp.h ZDConfig.c ZDConfig.h ZDNwkMgr.c ZDNwkMgr.h ZDObject.c ZDObject.h ZDProfile.c ZDProfile.h ZDSecMgr.c ZDSecMgr.h
  group ZMac
    ../../../../Components/zmac/f8w/: zmac.c zmac_cb.c zmac_internal.h
    ../../../../Components/zmac/: ZMAC.h
  group ZMain
    ../../ZMain/TI2530ZNP/: chipcon_cstartup.s51 OnBoard.c OnBoard.h ZMain.c
